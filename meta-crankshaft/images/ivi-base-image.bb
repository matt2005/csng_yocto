SUMMARY = "IVI image sata"

include recipes-sato/images/core-image-sato.bb

IMAGE_FEATURES += "package-management splash"
