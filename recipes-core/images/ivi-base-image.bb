SUMMARY = "IVI Base image"

inherit core-image
require ../../meta/recipes-sato/images/core-image-sato.bb

LICENSE = "MIT"
